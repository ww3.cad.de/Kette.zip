# Autodesk Inventor assembly: Kette
## iProperties
Created: 2005-10
Part Number: Kette
Document SubType Name: Assembly
Designer: Michalik
Author: Michalik
